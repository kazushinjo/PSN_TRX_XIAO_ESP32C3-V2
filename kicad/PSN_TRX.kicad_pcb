# Repository kazushinjo/PSN_TRX_XIAO_ESP32C3-V2

File README.md (part):

# PSN_TRX_XIAO_ESP32C3-V2

Seeed Studio XIAO ESP32C3 + Si5351 を使用した PSN 方式 SSB トランシーバー（KiCad 10.0）。

> [!IMPORTANT]
> **このリポジトリ（V2）の更新は 2026-11-20 で終了し、以後の変更は [PSN_TRX_XIAO_ESP32C3-V2.1](https://github.com/kazushinjo/PSN_TRX_XIAO_ESP32C3-V2.1) で行います。** V2 は 2026-11-19 の変更（部品の移動と配線のやり直し、L15 330nH・J2 穴 φ1.6・C110 追加、C60 の部品形の変更、部品実装図の段階組立版など）を入れる前の版として、このまま残します。

> **V2 Ver 1.4（作業中）**: [PSN_TRX_XIAO_ESP32C3](https://github.com/kazushinjo/PSN_TRX_XIAO_ESP32C3) を元に、受信部をダイレクトコンバージョンから SSB のシングルスーパー（IF 12MHz・ラダーフィルタ・積検波）に変更した。回路図・基板（134.1 × 129.7mm、配線済み・DRC エラー 0）・ファームウェア（ビルドのみ）・部品表・シミュレーションは V2 に更新済み。**実機は未確認**。製造データ（ガーバー・JLCPCB 用ファイル、`kicad/production/`）は 2026-11-11 に V2 Ver 1.4 の基板から `kicad/make_production.py` で出力済み（基板シルク「V2 Ver 1.4」）。部品実装図（`docs/PSN_TRX_部品実装図.pdf`、ブロック別 13 ページ＋調整箇所）・部品配置図（`kicad/PSN_TRX_部品配置図.pdf`）・調整手順（[`manual/調整手順.md`](manual/調整手順.md)）・操作説明書（[`manual/README.md`](manual/README.md)）・送信 I/Q の調整手順、組み立て説明書・評価試験報告書・回路図論理検証レポート・VFO 改造仕様書（docx）は V2 Ver 1.4 に更新済み。

## 概要

50MHz 帯 PSN（位相シフト網）方式 SSB トランシーバー。VXO（水晶発振器）を
Si5351A クロックジェネレーターによる VFO に置き換え、Seeed Studio XIAO ESP32C3 でデジタル制御する。

Si5351 の CLK0（0°）/ CLK1（90°）二相出力を直接バランスドモジュレーターへ供給することで、
従来の RF PSN（RC 位相シフト回路）も不要となる。

## 主な仕様

| 項目 | 内容 |
|---|---|
| クロックジェネレーター | Si5351A（AE-Si5351A モジュール、I2C 制御） |
| 周波数範囲 | 50.000 〜 52.900 MHz（6m バンド。52.90 〜 54.00 MHz は実験・研究用の区分なので出さない） |
| 受信方式（V2） | SSB シングルスーパー: 入力同調 L1 → RF 増幅 Q2・Q3（2SK192A-BL カスコード、AGC 付き）→ 出力同調 L2 → 第 1 混合 U1（NJM2594V）→ 混合後増幅 Q5・L 整合 → 12MHz ラダーフィルタ（水晶 6 個）→ IF 増幅 Q6・Q7（2SK192A-BL カスコード、AGC）→ 積検波 U2（NJM2594V）→ AF 前置増幅 Q9 → AF 段 |
| CLK0 出力 | 送信中: 0° → C74・LPF（L8）・VR3 → バランスドモジュレーター 1（D4/D5）。受信中: 第 1 局発（表示周波数 − BFO、38〜41MHz）→ Q4 → L3 → U1 |
| CLK1 出力 | 送信中だけ 90° → C75・LPF（L9）・VR4 → バランスドモジュレーター 2（D6/D7） |
| CLK2 出力（V2） | 受信中だけ BFO（約 12MHz、PLLB）→ R19・R20 → U2。USB はフィルタの通過域の下端の外、LSB は上端の外（シリアルの `bfo usb <Hz>` / `bfo lsb <Hz>` で合わせて保存） |
| 電波の型式（送信） | **SSB（USB、J3E）** と **AM（A3E）**。設定モードの **SSB/AM** で切り替え（LCD の t1 にいつも SSB / AM と出る。50MHz 帯なので LSB はパネルでは選ばない。シリアルの `sb lsb` は残す）。受信はどちらも USB |
| AM 送信 | 回路の変更なし。I/Q の出口はコンデンサ結合で直流の搬送波を出せないため、DSP で「(搬送波 + 音声) × cos(4 kHz)」を作って複素 FIR で I/Q にし、送信局発を表示周波数 − 4 kHz にして表示周波数に搬送波を出す。音声 約 160 Hz〜2.5 kHz（占有 ±2.5 kHz）。変調度は設定モードの **AM DEPTH**（10〜100 %、5 % 刻み、初期値 80 %、回すとすぐ反映）またはシリアルの `amd <%>`。AM のときは LCD の t1 に **AM** と出る（SSB のときは **SSB**）。キャリアの漏れが表示周波数 − 4 kHz に出るので VR5・VR6 を十分に合わせる |
| AM 受信 | 専用の検波回路はなく、AM の上側の側波帯を USB として受ける（表示周波数を相手の搬送波にぴったり合わせる。ずれは STEP 10Hz か RIT で ±20〜30Hz 以内に）。フィルタは SSB 用（約 2.4kHz 幅）で、受信音は XIAO に入らないのでソフトでの AM 復調はしない。聞き方は操作説明書 4.6 |
| チューニングステップ | 10Hz / 100Hz / 1kHz / 10kHz / 100kHz。今のステップは周波数の桁の下の白い下線で示す。ダイヤルで周波数を変えると、ステップより下の桁は 0 にそろう |
| 表示 | Nextion NX4832K035（3.5 インチ シリアル LCD、標準。TJC4832T135_011 も可）または OLED SSD1306 128×64（コンパイル時に選択） |
| 周波数記憶 | NVS（電源 OFF 後も保持） |
| S メーター・AGC | V2: IF 増幅（Q6・Q7）の出力を Q8 で増幅して AD8307（対数検波、25mV/dB）で測り、ADS1015（秋月 AE-ADS1015、I2C 0x48）で XIAO が読む。AGC は Q21 で RF 増幅 Q3・IF 増幅 Q7 のゲートを下げる（FAST / SLOW / OFF）。調整値はスケッチの RSSI_S9_MV・AGC_TARGET_MV |
| RIT | ±9.99 kHz・10 Hz 刻み。設定モードで RIT を選んでいる間は、値を LCD の t5 にだけ出す（0 でも RIT +0.00k）。送信中は自動で外す（送信検出を使うため基板 Ver 1.3 から。Ver 2.0 から送信検出は D0） |
| 送信 I/Q 生成 | マイク → U5A（約 21 倍）→ A2 の ADC（32kHz）→ 複素 FIR（16kHz、127 タップ、300〜2700Hz）→ I2S の PDM で D10（I）・D8（Q）→ 2 段 RC → 変調器（基板 Ver 2.0 から）。調整はシリアルのコマンド（mic・out・iqd・iqa・sb・amd・tone・alc）。デジタル ALC（FIR の前、効き始め -20 dBFS）で過変調と変調器ドライブ（Q15・Q16）のひずみを防ぎ、送信中はメーターを ALC メーターに |
| 操作 | エンコーダを押すと設定モード（ダイヤルで RIT / STEP / SSB/AM / AM DEPTH / AGC / LOCK を選び、押して値の変更、もう一度押して確定）。STEP の変更中は右に回すと下の桁、左に回すと上の桁へ下線が動く。電源投入直後の 5 秒は Welcome 表示（この間は電波を出さない） |

## ハードウェア構成

```
Seeed Studio XIAO ESP32C3 ─ メインコントローラ
├── Si5351A モジュール (AE-Si5351A) ─ I2C クロックジェネレーター
│   ├── CLK0  送信中 0° → バランスドモジュレーター 1（D4/D5）／受信中 第 1 局発 → Q4 → L3 → U1
│   ├── CLK1  送信中だけ 90° → バランスドモジュレーター 2（D6/D7）
│   └── CLK2  受信中だけ BFO → R19・R20 → U2（積検波）
├── ADS1015 モジュール（I2C 0x48）─ A0 = AD8307 の出力（S メーター・AGC）
├── Nextion NX4832K035 LCD（D6/D7 UART）または OLED（D4/D5 I2C）
├── ロータリーエンコーダ（A=D3, B=D1, SW=D9）
├── A2: 送信中のマイク音声（U5A → C65・R52、R73/R74 で 1.65V バイアス）→ 複素 FIR で I/Q を作る
│        （V2 では受信音は来ない）
├── D10: 受信中は AGC の PWM（→ R75・C104 → R76 → Q21 で Q3・Q7 のゲートを下げる）
│        送信中は PDM の I（→ R53・C66・R54・C67 → C70 → Q15）
├── D8: PDM の Q（→ R55・C68・R56・C69 → C72 → Q16、送信中だけ出力）
└── 送信検出 D0（TX12V → R77/R78 → Q22、送信中 LOW）

  受信と送信はリレー K1 で電源（RX12V／TX12V）が切り替わるので、A2・D10 を送受で使い分けられる。
  D0（GPIO2、送信検出）と D9（GPIO9、エンコーダの SW）は起動設定ピンなので、PTT やつまみを押したまま電源を入れない

1W PA: RD06HVF1 (N-ch RF MOSFET) @ 12V, Class AB
```

## LCD の表示（Nextion NX4832K035）

下の 2 枚は、画面データ `PSN_TRX_XIAO_ESP32C3/nextion/PSN_TRX_K035.HMI` を Nextion Editor 1.68.2 のシミュレータで開き、スケッチが受信中に LCD へ送るのと同じ命令を入れて表示させたものです（実機の写真ではありません。S7・AGC SLOW・AGC -6dB は見本の値です）。各部の意味は [操作説明書 4.2](manual/README.md#42-表示の見かた) を見てください。

### テキスト部品 t0〜t7 の配置

背景画像の上に、画面データの t0〜t7 の位置（x・y・w・h）を描いた図です（`docs/tools/make_lcd_layout.py`）。t0 = 周波数、t1 = SSB／AM・LOCK（設定モード中はメニュー）、t2 = 機種名、t3 = S メーター／ALC、t4 = AGC／TX、t5 = RIT、t6 = AGC の量／送信時間、t7 = 電源電圧。ステップの下線は t0 と t1 のすき間（y 72〜74）にスケッチが描きます。値は [画面データ作成手順 5 章](PSN_TRX_XIAO_ESP32C3/nextion/画面データ作成手順.md) の表と同じです。

### AM モード（バンドプランの区分の中）

設定モードの **SSB/AM** を AM にすると、t1 に **AM** が出ます（SSB のときは **SSB**）。

> この 2 枚は 2026-11-28 より前の表示です。今は t1 に `STEP: 1kHz` は出ず、ステップは周波数の桁の下の白い下線で示します（t1 はこの例なら `AM` だけ）。51.050.000 MHz は AM の区分（51.000〜52.900MHz）の中なので、周波数は白です。

### バンドプランから外れたとき（周波数が赤）

送信する電波が JARL のバンドプラン（令和 7 年 7 月 17 日施行）の区分から外れる周波数では、**周波数の文字が赤** になります。この例は AM で 50.620.000 MHz にしたところです。AM の電波（50.6175〜50.6225MHz）が AM の区分（51.000MHz から）より下にあるので赤になります（50.070〜51.000MHz は占有 3kHz 以下の狭帯域で、AM は含まない）。白になる範囲は次のとおりです。

| 電波の型式 | 周波数が白になる範囲（表示周波数） | 判定に使う幅 |
|---|---|---|
| USB | 50.070 〜 52.897 MHz | 表示周波数から 3kHz 上まで（SSB_MIN_HZ〜BAND_MAX_HZ に入ること） |
| AM | 51.0025 〜 52.8975 MHz | 表示周波数の上下 2.5kHz ずつ（AM_MIN_HZ〜BAND_MAX_HZ に入ること） |

赤のままでも受信と送信はできますが（警告だけ）、赤いまま送信しないでください。色はスケッチが `t0.pco`（白 65535 / 赤 63488）で切り替えるので、画面データ（.tft）を書き込み直す必要はありません。

## 基板パターン

基板は 134.0 × 129.6mm の 4 層（内層 1 = GND ベタ、内層 2 = 電源ベタ）。下の図は V2 Ver 1.4 の基板（`kicad/PSN_TRX.kicad_pcb`）から KiCad 10 の `kicad-cli pcb export svg` で出力した。

### 表面（部品面、F.Cu とシルク）

### 裏面（はんだ面、B.Cu とシルク、裏から見た向き）

## 1W パワーアンプ（Q19）

前段（2SC1815 等）の出力（約 20〜30mW）を増幅する終段アンプ。

| 項目 | 内容 |
|---|---|
| トランジスタ | **RD06HVF1**（三菱電機 N-ch RF MOSFET, 175MHz, 6W, TO-220F） |
| 電源電圧 | 12V |
| 動作クラス | Class AB |
| 静止電流 Idq | 200〜400mA（VR7 で調整） |
| 出力 | 約 1W @50MHz |
| 出力 LPF | 7 素子チェビシェフ＋2 倍波トラップ: C94（0.001µF、直流カット）→ C98 39pF → L16（T-50-10 9T）→ C99 82pF＋TC3 30p → L17（10T）→ C101 100pF ∥ トラップ（L18 T-30-6 8T ＋ C100 5pF ∥ TC4 10p、TC4 で 103MHz に合わせる）→ L19（8T）→ C102 68pF → K1。C98 には Q19 の出力容量 Coss 約 18pF が並列に入る。TC4 を合わせると 2 倍波 −70〜−76dB、3 倍波 −75〜−80dB、挿入損失 0.41〜0.53dB（計算値） |
| 電源 | 送信 12V（リレー K1 の NO 側）、RFC1 10µH 経由。バルク C96 100µF |

### バイアス回路

```
送信12V → R70(330Ω) → VR7(500Ω) の 1 番 ─ VR7 の 3 番 → GND
                         VR7 ワイパー(2 番) → R69(10Ω) → Q19 ゲート
```

- ゲート電圧の可変範囲は 0〜約 7.2V（13.8V 電源では約 8.3V）。**最初の送信前に VR7 を GND 側（ゲート 0V）いっぱいに回しておく**（上側いっぱいだと電流が流れすぎて Q19 を壊すおそれがある）
- 無変調で送信し、VR7 を少しずつ回してドレイン電流 (Idq) を 200〜400mA に合わせる。RD06HVF1 のしきい値電圧 Vth は 1.9〜4.9V（データシート）で、データシートの代表特性では Vgs 約 4V から電流が流れ始め、約 5V で 0.3A。合わせたときのゲート電圧は個体によって 4〜6V 程度になる。電流は Vgs に対して急に増えるので、5V を超えたらゆっくり回す
- Q19 のソースは GND 直結

詳細は `docs/PSN_TRX_VFO改造仕様書.docx` を参照。

### ヒートシンク

RD06HVF1（Q19）には秋月電子 **17PB046**（GEC ヒートシンク、46.2×17×25mm、黒アルマイト、熱抵抗 11.9℃/W）を使用（基板 Ver 1.5 から。それまでは 20PB020、15.8℃/W）。
Q19 のタブを基板図の上側（HS1 側）に向け、タブの M3 穴でヒートシンクの取付面にネジ止めする。17PB046 は断面 46.2 × 17mm のうち、取付面からフィン側が 10mm、反対の Q19 側に両端のつば（厚さ約 1.3mm、長さ 7mm）が出ている。Q19 はつばの間に入る（V2 Ver 1.3 で部品形の外形をつば付きの実物どおりに直し、つばに当たっていた L15・L16 を移した）。ヒートシンクの脚ピン（φ1.4、ピッチ 30mm、取付面から 3mm）用に、基板へ φ1.6 の穴（NPTH）を 2 個設けている（HS1）。M3 ねじ穴は基板面から 19mm の高さ。
高さは 20PB020 と同じ 25mm なのでケースはそのまま使える。ヒートシンクの右端がふた上の LCD 基板の下に入らないよう、Q19 とヒートシンクは Ver 1.4 より 2.5mm 左にある（LCD 基板の端から約 1.5mm 離れる）。

## シミュレーション結果（ngspice）

回路図のネットリストから定数を直接読み込み、KiCad 同梱の ngspice（libngspice）で計算した結果です（V2 Ver 1.4、2026-11-11）。項目ごとの説明と実機で確かめる点をまとめた報告書は [`docs/PSN_TRX_シミュレーション結果.md`](docs/PSN_TRX_シミュレーション結果.md)（PDF 版 `docs/PSN_TRX_シミュレーション結果.pdf`）。スクリプトと全結果は [`kicad/sim/`](kicad/sim/) にあり、`./run.sh` で再計算できます（結果は `kicad/sim/results.txt`）。トランジスタはデータシートの代表値から作った簡易モデルなので、実機では測定で確認してください。

### PA 出力 LPF（5 素子 → 7 素子＋2 倍波トラップ）

LPF だけの周波数特性（50Ω 終端、10〜500MHz）。左が Ver 1.7 までの 5 素子、右が Ver 1.8 の 7 素子＋101MHz トラップ（TC4 を合わせた状態）。

PA 出力のスペクトル。PA（RD06HVF1、シングル AB 級）自身の高調波を 2 倍波 約 −20dBc・3 倍波 約 −27dBc とし、上の LPF を通した値です。出力に対する比（dBc）で読む図です（図のタイトルの「10W」は計算時の基準値で、本機の出力は約 1W）。破線は 1W を超える場合の許容値 −60dBc。

| | 5 素子（Ver 1.7 まで） | 7 素子＋トラップ（Ver 1.8、TC4 調整後） |
|---|---|---|
| LPF の減衰（2 倍波 101MHz） | −27〜−31dB | −70〜−76dB |
| LPF の減衰（3 倍波 151.5MHz） | −47〜−51dB | −75〜−80dB |
| 挿入損失（50.5MHz） | 約 0.17dB | 0.41〜0.53dB |
| 出力の 2 倍波（図の例） | −50.5dBc | −94.5dBc |
| 新スプリアス規定（1W 以下 −43dBc／1W 超 −60dBc） | 1W 超では満たさない | 満たす見込み |

減衰の範囲は、L19/L16/L17 ±7%・Q19 の出力容量 18〜25pF・トラップのコイル ±7% のすべての組み合わせでの値です。**TC4 を合わせないと 2 倍波が −30dB 程度に戻ることがある**ので、組み立て後に 51.5MHz の 2 倍波（約 103MHz）が最小になるよう TC4 を調整してください（101MHz に合わせたままだと 52〜52.9MHz で 2 倍波が −47〜−53dBc になる。103MHz に合わせると 50.07〜52.9MHz の全域で −69dBc 以下、`kicad/sim/band.py`）（manual/調整手順.md の手順 9、組み立て説明書 7 章）。規定への適合は実測（スペクトラムアナライザ）で確認が必要です。

### 受信の前段の利得

前段の利得は R5（2.2kΩ）と L2 のタップ（RX12V 側から 3 回目）で約 23dB に抑えています（10kΩ なら +28dB・雑音指数 1.0dB だが、混合器に入る信号が 8dB 大きくなる）。その分は Q9 の利得（R29 ÷ R28 ≒ 12）で戻しています。

### そのほかの主な結果

| 項目 | 結果 |
|---|---|
| 直流動作点（電源 11/12/13.8V、hFE 下限〜上限） | 全段とも正常範囲。AF 出力段のアイドル 37〜68mA（R41 最大 0.47W、1W 品）、Q18 最大 0.21W |
| 2SK192A-BL カスコード（Q6・Q7、IF 増幅） | R18 100Ω で個体差により 4.6〜10.5mA（標準 7.4mA）。R18 で 5〜8mA に合わせる |
| 2SK192A-BL カスコード（Q2・Q3、RF 増幅、V2） | Id 約 7.4mA（R3 100Ω、個体差で 4.6〜10.5mA）、Q3 の損失 最大 63mW（許容 200mW）、ゲート・ドレイン間 最大 13.8V（耐圧 18V） |
| 送信 AF 系（マイク → A2） | 1kHz 基準で 300Hz 0〜+0.1dB、2700Hz −0.5dB。マイク 1Pa（1kHz）で U5A の出力 約 330mVrms、A2 に約 230mVrms。U5A は 3Pa（103.5dB SPL）付近から頭打ち |
| 送信 AF 系（PDM 出力 → 変調器入力） | 1kHz 基準で 300Hz 0dB、2700Hz −0.4dB。PDM の 78kHz で −30dB 以下 |
| I/Q 位相差 | 90° からのずれ 0°（FIR の計算）→ 逆側帯波の抑圧 約 70dB。RC が I/Q で ±3% ずれると最大 2.1°（約 32dB）、iqd・iqa で補正して約 50dB（下の図） |
| 受信 AF 系（積検波 U2 → Q9 → スピーカー、V2） | 1kHz 基準で 300Hz +0.3dB、2700Hz −2.0dB、利得 41.9dB（音量 0.9）。歪み率 1% 以下は 3.8mW まで、3% 以下は 23mW、10% 以下は 76mW、最大 約 113mW |
| 受信の前段（V2、入力同調 → Q2・Q3 → 出力同調） | 電力利得 +22.6dB、雑音指数 0.88dB（2SK192A-BL・R3 100Ω）。−3dB 帯域 49.2〜51.9MHz。イメージ（26.5MHz）−48dB、半 IF（44.5MHz）−20dB、局発の漏れ −32dB。TC1・TC2 は約 11.0pF・18.5pF。AGC で −15.7dB（Q3 のゲート 1V で −3.9dB、0V で −15.7dB） |
| ラダーフィルタ（V2、水晶の運動定数は仮定） | 損失 6.1dB、−6dB 幅 2.56kHz、−60dB 幅 7.7kHz、リップル 3dB。終端は両側 330Ω（入力は L4・C16 の L 整合） |
| 受信のレベル配分（V2、NJM2594 の変換利得 0dB と仮定） | アンテナ端 → 積検波の入力 +60.1dB。S9 で積検波の出力 約 50mV、スピーカーは出力段の最大（約 113mW）。AD8307 の入力 S1 −52dBm・S9 −4dBm |
| 受信の全体（V2、アンテナ → スピーカーを通した計算、full.py） | アンテナ → スピーカー 約 +101dB（1kHz、音量 0.9。小信号の線形計算なので、S9 のスピーカー出力は線形の値（約 4.3W 相当）ではなく出力段の最大 約 113mW で頭打ち）。音声の −6dB 帯域 300〜2830Hz。逆側帯波 −33dB（1kHz）・−49dB（2kHz）、隣接 +5kHz −69dB・−5kHz −78dB、イメージ −48dB。前段の雑音指数 0.9dB・電力利得 +22.6dB、混合器の雑音指数を 10〜15dB として全体 1.0〜1.4dB、最小検出信号 約 −139dBm（帯域 2.4kHz） |
| 送信の全体（V2、局発・変調器 → PA → LPF → 50Ω の過渡解析、full.py。7T50 の値は仮定） | 変調器の音声入力 100mV で 114mW、400mV で 1.28W、800mV で 1.68W（最大 約 1.7W、2 倍波 −67〜−90dBc）。キャリアの漏れは VR5・VR6 の中点で −1dBm、合わせると −25dBm（計算の刻みによる。実機は −30dBm 以下が目標）。I と Q の RF 側の位相差は中点で 93.2°（RF 側だけで抑圧 31dB）→ VR3・VR4 で 90° に合わせ、振幅の差を iqa で補正すると 40dB 以上 |
| ブロックごとの確認（blocks.py、2026-11-05） | 7T50（FCZ 07S50、0.51〜0.80µH）は L3・L12〜L14 ともコアの範囲内。U1 のキャリア入力 約 350mVrms、U2（BFO）約 100mVrms。IF・S メーターの同調ずれは 12MHz で 0.5dB 以下の差で変更不要。送信表示の LED は約 10mW 以上で点灯。Q1 は十分飽和 |
| PA 入力 | C92 150p → C93 33p（GND へ）→ L15 270nH の L 型整合（V2 Ver 1.4）。50Ω 源に対し不整合損失 0.2〜0.4dB（50〜51MHz で 0.5dB 以下） |
| DC-DC 入力フィルタ | 共振 16kHz のピーク 1.5〜4.1Ω。R-78E の負性入力抵抗より十分小さく安定 |
| AGC | PWM の平均 0.55〜0.80V でゲートが 4.0V → 0.1〜0.2V。RF 増幅（Q3）−15.7dB ＋ IF 増幅（Q7）−15.5dB で計 約 −31dB |

### 送信 I/Q の位相差

AF の周波数を 100〜3200Hz でスキャンし、I と Q の位相差の 90° からのずれ（上）、振幅差（中）、そこから決まる逆側帯波の抑圧（下）を計算したもの。U7 の FIR はファームウェアと同じ係数（int16 に丸めた後）、その後ろの RC〜変調器入力は ngspice で計算しています（`kicad/sim/iq_scan.py`）。FIR は I 側が左右対称・Q 側が逆対称の係数なので位相差はちょうど 90° になり、抑圧は振幅のわずかなリップルで決まります。RC がずれたときのずれは周波数に比例する（遅延の差になる）ので、`iqd`（遅延差）・`iqa`（利得差）でほぼ打ち消せます。3.3kHz より上は FIR の阻止域（出力がほぼ 0）なので表示していません。

### 不要側波帯の抑圧比

上は音声周波数ごとの抑圧比、下は試験トーン 1kHz（`tone 1000`、USB）を送信したときにスペクトラムアナライザで見える形です（`kicad/sim/sideband.py`）。部品が定数どおりなら約 70dB、RC が I/Q で ±3% ずれても `iqd`・`iqa` の補正で約 50〜60dB。ただし RF 側（Si5351 の 2 出力・変調器）に 1°・0.1dB のずれがあるだけで約 39dB になり、実機の抑圧比はほぼ RF 側で決まります（RF 側は計算に含めていないので、参考の線として重ねています）。

実機での `iqd`・`iqa` の合わせ方（試験トーンと SDR・受信機を使う手順、記録表つき）は [`manual/送信IQ調整手順.md`](manual/送信IQ調整手順.md) にまとめています。

詳しい数値は評価試験報告書 6.5 と JLCPCB 提出資料 4.1・4.2 にまとめています。

### バンドの全域（50.07〜52.90MHz、2026-11-25）

JARL のバンドプラン（令和 7 年 7 月 17 日施行）に合わせて周波数範囲を 50.000〜52.900MHz に広げた（2026-11-25）ので、使う範囲の 50.07〜52.90MHz で受信・送信を計算しました（`kicad/sim/band.py`。回路・仮定は rx.py・blocks.py・full.py と同じで、50.5MHz を各周波数に置き換えて計算）。

**受信の前段**（アンテナ → 混合器の入力、50.5MHz を 0dB）

| | 50.07MHz | 50.50MHz | 51.00MHz | 51.50MHz | 52.00MHz | 52.50MHz | 52.90MHz |
|---|---|---|---|---|---|---|---|
| TC1・TC2 を 50.5MHz で合わせる | −0.3 | 0.0 | −0.4 | −1.6 | −3.3 | −5.1 | **−6.7** |
| **TC1・TC2 を 51.45MHz で合わせる**（TC1 10.0p・TC2 17.75p） | −1.4 | 0.0 | +1.1 | +1.5 | +1.0 | −0.1 | −1.4 |

**第 1 局発 L3**（U1 のキャリア入力。L3 を 38.5MHz に合わせたときの 38.5MHz を 0dB、表は受信周波数）

| | 50.07MHz | 50.50MHz | 51.00MHz | 51.50MHz | 52.00MHz | 52.50MHz | 52.90MHz |
|---|---|---|---|---|---|---|---|
| L3 を 38.5MHz（受信 50.5MHz）で合わせる | −1.2 | 0.0 | −1.6 | −4.5 | −7.0 | −9.0 | **−10.4** |
| **L3 を 39.5MHz（受信 51.5MHz）で合わせる**（0.533µH） | −7.1 | −4.9 | −1.9 | 0.0 | −1.4 | −4.2 | −6.3 |

**送信**（電源 12V、L12〜L14 は 50.5MHz で合わせたまま、音声 800mV（`out` を上げきった飽和、約 1.7W）。出力と 2 倍波 dBc）

| | 50.07MHz | 50.50MHz | 51.00MHz | 51.50MHz | 52.00MHz | 52.50MHz | 52.90MHz |
|---|---|---|---|---|---|---|---|
| TC4 6.5pF（101MHz 付近） | 1.34W −76 | 1.47W −74 | 1.60W −70 | 1.71W −62 | 1.78W **−53** | 1.80W **−47** | 1.77W **−52** |
| **TC4 5.4pF（103MHz）** | 1.31W −82 | 1.42W −80 | 1.54W −75 | 1.63W −95 | 1.70W −81 | 1.72W −75 | 1.71W −69 |

- 受信の前段・局発は、50.5MHz で合わせたままだと 52.9MHz で前段 −6.7dB・局発 −10.4dB（約 110mVrms。NJM2594 の目安 100mVrms ぎりぎり）まで下がる。**TC1・TC2 を 51.45MHz、L3 を 51.5MHz で合わせる**と、全域で前段 ±1.5dB、局発 約 160mVrms 以上（38.5MHz で合わせたときの最大 354mVrms に対し −7.1dB）になる。
- 音声 200mV（小信号）では、同じ `out` で 50.5MHz 0.23W → 52.9MHz 0.76W（約 +5dB）。電力の上限は **使う範囲の一番高い周波数** で `out` を合わせて守る。
- **TC4 を 101MHz のままにすると、52〜52.9MHz で 2 倍波が −47〜−53dBc になり、規定（1W を超え 50W 以下は −60dBc）を満たさない**。TC4 で 2 倍波トラップを 103MHz（51.5MHz の 2 倍）に合わせると、全域で −69dBc 以下になる。
- Si5351 の PLL は、送信 52.9MHz × 16 = 846MHz、受信の局発 約 40.9MHz × 20 = 818MHz で、どちらも上限 900MHz 以内。
- 調整の変更は `manual/調整手順.md` の手順 3・4・9・13 に反映した。

## KiCad ライブラリ状態

| ファイル | 状態 |
|---|---|
| `kicad/PSN_TRX.pretty/` | 全12フットプリント KiCad 10 形式 ✅ |
| `kicad/PSN_TRX.kicad_sym` | カスタムシンボル（RD06HVF1 含む）✅ |
| `kicad/fp-lib-table` | PSN_TRX ライブラリ登録済み ✅ |
| DRC ライブラリエラー | **0件** ✅ |

## ファイル構成

```
kicad/
  PSN_TRX.kicad_sch       - 回路図
  PSN_TRX.kicad_pcb       - PCB レイアウト（配線済み、DRC 0）
  PSN_TRX.kicad_sym       - カスタムシンボルライブラリ
  PSN_TRX.pretty/         - カスタムフットプリントライブラリ（12点）
  BOM.md                  - 部品表（Markdown・購入先と購入先の型番付き）
  bom.csv                 - 部品表（kicad-cli で回路図から出力した CSV）
  bom_purchase.csv        - 購入用部品表（購入先・型番・販売コード・入数・価格、UTF-8 CSV）
  make_bom_purchase.py    - bom.csv から bom_purchase.csv を作り BOM.md に購入先を入れるスクリプト
  sim/                    - ngspice によるアナログ部の計算（run.sh → results.txt、iq_scan.py・sideband.py → I/Q 位相差・抑圧比のグラフ）
  production/             - JLCPCB 提出用（ガーバー zip・CPL・BOM・提出資料）
PSN_TRX_XIAO_ESP32C3/
  PSN_TRX_XIAO_ESP32C3.ino - XIAO ESP32C3 のスケッチ（VFO・表示・S メーター・AGC）
  tx_dsp.cpp / tx_dsp.h    - 送信 I/Q の生成（ADC・複素 FIR・PDM）と受信音のサンプリング（Ver 2.0）
measure/spurious/
  README.md               - 新スプリアス規格の測定手順（JARD 提出用、DSA815-TG・LAN、定格 1W）
  jard_spurious.py        - 測定の自動化スクリプト（idn / pathloss / monitor / measure、--dry-run で測定器なしでも動く）
docs/
  PSN_TRX_VFO改造仕様書.docx  - VFO 仕様書（Si5351・XIAO の接続、局発・BFO、送信 I/Q、PA）
  PSN_TRX_組み立て説明書.docx  - 組み立て説明書（部品の取り付け・配線・調整の流れ）
  PSN_TRX_評価試験報告書.docx  - 評価試験報告書（ERC・DRC・配線長・計算・シミュレーション）
  PSN_TRX_シミュレーション結果.md / .pdf - アナログ部シミュレーションの報告書（kicad/sim の結果を項目ごとにまとめたもの）
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
## KiCad design kicad/PSN_TRX.kicad_pcb

File kicad/README.txt:

PSN_TRX_XIAO_ESP32C3-V2 完全KiCadプロジェクト（V2 Ver 1.4）

【このフォルダの開き方】
1. KiCad 10 のプロジェクトマネージャで「ファイルを開く」→ PSN_TRX.kicad_pro を選択
   （※ .kicad_sch や .kicad_pcb を直接開くとライブラリが解決されません。
      必ず .kicad_pro から開いてください）
2. 基板エディタで「検査 → デザインルールチェッカー(DRC)」を実行
   （シルク警告3件は修正済み。残る場合は除外で可）
3. 発注用のデータは「python3 make_production.py」で作り直せます（ガーバー・ドリル・JLCPCB 用 BOM/CPL・座標・部品配置図）
   （同梱の production/ は 2026-11-08 に基板 V2 Ver 1.3 から DRC エラー0・未配線0・回路図との不一致0 の状態で出力済み）

【含まれるもの】
- PSN_TRX.kicad_pro / .kicad_sch / .kicad_pcb / .kicad_sym / .kicad_prl
- sym-lib-table / fp-lib-table（カスタムライブラリは ${KIPRJMOD} 参照＝このフォルダ内完結）
- PSN_TRX.pretty/（カスタムフットプリント21種: XIAO ソケット（2026-11-05 に Seeed 公式の並びに修正）, Si5351 モジュール用 DIP-8（同、ピン番号を修正）, 電源線・同軸じか付け用 SolderWire_1x02（5.08mm・2.54mm、穴 φ1.1）, AL0510 縦置き, 7T50 コイル, T30/T50 トロイダル, TMCV01 トリマ, Heatsink_17PB046 等）
- blank.kicad_wks（図枠テンプレート）
- report.txt（回路図→基板 反映ログ: 警告0/エラー0）
- BOM.md / bom.csv（部品表）
- refdes_map_2026-11-05.csv（部品番号の新旧対応表。2026-11-05 に部品番号を信号の流れの順に振り直した）
- refdes_map_2026-10-15.csv（その前の対応表。2026-10-15 に部品番号を回路図の位置順に振り直した）
- bom_purchase.csv（購入用部品表: 購入先・型番・秋月の販売コード・入数・価格）／make_bom_purchase.py（その作成スクリプト）
- production/（JLCPCB 用製造データ、2026-11-08 に V2 Ver 1.3 から make_production.py で出力）
    PSN_TRX_Gerber_JLCPCB.zip … ガーバー11層＋ドリル(PTH/NPTH)＋ジョブファイル。発注時はこれだけアップロード
    PSN_TRX_BOM_JLCPCB.csv / PSN_TRX_CPL_JLCPCB.csv … 実装も頼む場合の部品表・座標（LCSC 番号は未記入）
    発注指定: 4層、1.6mm、134.1×129.7mm、最小穴 0.3mm、最小線幅 0.2mm・間隔 0.2mm（いずれも標準仕様内）
- PSN_TRX_部品配置図.pdf（A3・1ページ: 上面から見た部品外形と番号、裏面の Q7/Q6 は Q2 の真裏、2026-10-28 に基板 Ver 2.1 から出力。値は入れず部品番号のみ。値は docs/PSN_TRX_部品実装図.pdf の各ページの表を参照）

【標準ライブラリについて】
回路図・基板は KiCad標準ライブラリ（Device, Transistor_BJT, Regulator_Linear,
Diode_THT, Resistor_THT, Connector_PinHeader 等）も使用しています。
これらはKiCad 10インストーラに同梱されています。
「ライブラリが見つかりません」と出る場合は、KiCadインストール時に
「Libraries」にチェックが入っていなかった可能性があります。
その場合はKiCadインストーラを再実行し Libraries を追加してください。

Schematic: PSN_TRX.kicad_sch, 50Mhz PSN トランシーバ

Parts:
C1: 10p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C2, C3, C5, C6, C7, C9, C10, C12, C15, C22, C23, C25, C26, C29, C32, C33, C34, C51, C52, C54, C74, C75, C82, C83, C85, C87, C88, C89, C91, C110: 0.01u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C4, C100, C103: 5p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C8: 27p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C11, C13, C14, C27, C28, C30, C35, C36, C41, C42, C43, C49, C53, C64, C109: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C16, C84, C86, C90: 15p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C17, C21: 82p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C18, C20: 100p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C19: 120p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C24, C31: 33p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C37, C39, C40, C44, C45, C46, C104: 1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C38: 0.047u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C47, C48, C96: 100u; CP_Radial_D6.3mm_P2.50mm
C50, C55, C58, C61, C63, C105, C106, C107, C108: 10u; CP_Radial_D5.0mm_P2.00mm
C56: 47u; CP_Radial_D5.0mm_P2.00mm
C57, C62, C65, C70, C71, C72, C73: 1u; CP_Radial_D5.0mm_P2.00mm
C59: 0.01u; C_Radial_D5.0mm_P2.00mm_CPpad
C60: 0.068u; C_Radial_D5.0mm_P2.00mm_CPpad
C66, C67, C68, C69: 3300p; C_Disc_D5.0mm_W2.5mm_P2.50mm
C76, C77, C78, C79: 47PF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C80, C81: 0.001u; C_Disc_D5.0mm_W2.5mm_P2.50mm
C92: 150pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C93: 33pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C94: 0.001u; C_Disc_D5.0mm_W2.5mm_P5.00mm
C95, C97: 0.1uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C98: 39p; C_Disc_D5.0mm_W2.5mm_P5.00mm
C99: 82p; C_Disc_D5.0mm_W2.5mm_P5.00mm
C101: 100p; C_Disc_D5.0mm_W2.5mm_P5.00mm
C102: 68p; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
D2, D3: 1N4148; D_DO-35_SOD27_P2.54mm_Vertical_CathodeUp
D4, D5, D6, D7, D8, D9: 1N60; D_DO-35_SOD27_P2.54mm_Vertical_CathodeUp
D10: 1N5819; D_DO-41_SOD81_P5.08mm_Vertical_AnodeUp
J1: RF_IN; SolderWire_1x02_P2.54mm_D1.1mm
J2: PWR_IN; SolderWire_1x02_P5.08mm_D1.1mm
J3, J5: Volume; PinHeader_1x03_P2.54mm_Vertical
J4: AE-ADS1015; AE-ADS1015_Vertical
J6: SP-OUT; PinHeader_1x02_P2.54mm_Vertical
J7: MIC-IN; PinHeader_1x04_P2.54mm_Vertical
J8: I2C_OUT-LCD; PinHeader_1x03_P2.54mm_Vertical
J9: TX-ON-LED; PinHeader_1x02_P2.54mm_Vertical
J10: Encoder; PinHeader_1x04_P2.54mm_Vertical
J11: NX4832K035; PinHeader_1x04_P2.54mm_Vertical
J12: POWER-LED; PinHeader_1x02_P2.54mm_Vertical
K1: G5V-2 DC12; Relay_DPDT_Omron_G5V-2_D1.0mm
L1: T30-6 11T/2T; L_T30_3pin_Vertical
L2: T30-6 11T/3T; L_T30_3pin_Vertical
L3, L12, L13, L14: 7T50; L_FCZ07S_CT
L4: 8.2uH; L_AL0510-153K_Vertical
L5, L6: 4.7uH; L_AL0510-153K_Vertical
L7: 15mH; L_AL0510-153K_Vertical
L8, L9: 100nH; L_AL0510-153K_Vertical
L10, L11: 1mH; L_AL0510-153K_Vertical
L15: 330nH; L_Axial_L9.5mm_D4.0mm_P2.54mm_Vertical_Fastron_SMCC
L16: T-50-10 9T/0.6mm; L_T50_2pin_Vertical
L17: T-50-10 10T/0.6mm; L_T50_2pin_Vertical
L18: T-30-6 8T/0.4mm; L_T30_2pin_Vertical
L19: T-50-10 8T/0.6mm; L_T50_2pin_Vertical
L20: 10uH; L_AL0510-153K_Vertical
LED1: LED黄; PinHeader_1x02_P2.54mm_Vertical; not fitted
Q1: 2SA1015; TO-92_Inline
Q2, Q3, Q6, Q7: 2SK192A; TO-92_Inline
Q4, Q17: 2SK439; TO-92_Inline
Q5, Q8, Q9, Q10, Q11, Q14, Q15, Q16, Q18, Q20, Q21, Q22: 2SC1815; TO-92_Inline
Q12: 2SA950; TO-92_Inline
Q13: 2SC2120; TO-92_Inline
Q19: RD06HVF1; TO-220-3_Vertical
R1, R12, R23, R43, R61, R62, R67: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R39, R40, R75, R78, R79, R80: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3, R9, R18, R20, R68: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R4, R6, R29, R32, R35, R44, R48, R49, R71, R73, R74: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5, R21: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7, R65: 51; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R8: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R10, R27, R30, R31, R33, R36, R37, R42, R45, R50, R72: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R11, R22: 27k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R13, R34: 1.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R14: 33; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R15: 180; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R16, R38, R46: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R17, R51, R66: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R19: 1.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R24: 27; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R25: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R26: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R28: 8.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R41: 100 1W; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R47: 620; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R52: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R53, R54, R55, R56: 3.3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R57, R59: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R58, R60: 22; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R63, R64: 47; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R69: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R70: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R76, R77: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
RFC1: 10uH; L_Axial_L14.0mm_D4.5mm_P15.24mm_Horizontal_Fastron_LACC
TC1, TC2, TC3: 30p; C_Trimmer_TMCV01
TC4: 10p; C_Trimmer_TMCV01
U1, U2: NJM2594V; TSSOP-8_4.4x3mm_P0.65mm
U3: AD8307ANZ; DIP-8_W7.62mm
U4: 78L05; TO-92_Inline
U5: NJM2904; DIP-8_W7.62mm
U6: Si5351_DIP8; DIP-8_W7.62mm
U7: Seeeduino_XIAO_Socket
U8: R-78E5.0-1.0; DCDC_RECOM_R-78E_78Lxx-pinmap
U9: LP2950-3.3_TO92; TO-92_Inline
VR1, VR2: 10k; Potentiometer_TOCOS_GF063P_Vertical; not fitted
VR3, VR4: 500; Potentiometer_TOCOS_GF063P_Vertical
VR5, VR6: 1k; Potentiometer_TOCOS_GF063P_Vertical
VR7: 500; Potentiometer_Bourns_3266W_Vertical
Y1, Y2, Y3, Y4, Y5, Y6: 12MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C64.1, C107.1, D10.2 (A), J7.1, J11.4, R42.1, R48.1, U5.8 (V+), U8.1 (VO), U9.3 (VI)
/+12V: C109.1, C110.1, J2.1, K1.13, L20.1, Q1.1 (E), R2.1, R80.1
/PSN_I_OUT: C67.1, C70.1, R54.1
/PTT: J7.3, R1.2
/TX12V: C86.2, C87.1, C90.2, C91.1, C95.1, C96.1, C97.1, K1.9, L13.3 (SB), L14.3 (SB), R45.1, R61.1, R62.1, R66.1, R70.1, R72.2, R77.1, RFC1.1
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C11.2, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C27.2, C28.2, C30.2, C31.2, C33.2, C34.2, C35.2, C36.2, C38.2, C41.2, C42.2, C43.2, C47.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C59.2, C60.2, C63.2, C64.2, C66.2, C67.2, C68.2, C69.2, C76.1, C77.1, C78.1, C79.1, C82.2, C83.2, C85.2, C87.2, C89.2, C91.2, C93.2, C95.2, C96.2, C97.2, C98.2, C99.2, C100.2, C101.2, C102.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, D1.2 (A), D2.2 (A), D3.1 (K), D8.2 (A), J1.2, J2.2, J3.3, J4.2 (GND)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; also elsewhere on the board
unnamed: C5.2, C80.1, R63.1, VR3.1
unnamed: C10.1, R8.2, R9.1
unnamed: C14.1, R14.2, R15.1
unnamed: C15.2, C16.1, L4.1
unnamed: C17.1, Y1.2, Y2.1
unnamed: C18.1, Y2.2, Y3.1
unnamed: C19.1, Y3.2, Y4.1
unnamed: C20.1, Y4.2, Y5.1
unnamed: C21.1, Y5.2, Y6.1
unnamed: C26.1, R19.2, R20.1
unnamed: C29.1, R21.2
unnamed: C30.1, R24.2, R25.1
unnamed: C37.2, R28.1
unnamed: C38.1, C39.1, R31.2
unnamed: C40.2, C41.1, R34.1
unnamed: C44.2, R38.1
unnamed: C56.1, R42.2, R43.1
unnamed: C58.2, C59.1, L7.2
unnamed: C60.1, C61.1, L7.1
unnamed: C61.2, C62.2, R47.1
unnamed: C63.1, R50.2
unnamed: C65.1, R51.1, U5.1
unnamed: C65.2, R52.2
unnamed: C66.1, R53.1, R54.2
unnamed: C68.1, R55.1, R56.2
unnamed: C69.1, C72.1, R56.1
unnamed: C71.2, C82.1, L10.2
unnamed: C73.2, C83.1, L11.2
unnamed: C74.1, C76.2, L8.1
unnamed: C75.1, C78.2, L9.1
unnamed: C77.2, L8.2, VR3.2, VR3.3
unnamed: C79.2, L9.2, VR4.2, VR4.3
unnamed: C80.2, L10.1, VR5.2
unnamed: C81.1, R64.1, VR4.1
unnamed: C81.2, L11.1, VR6.2
unnamed: C92.2, C93.1, L15.1
unnamed: C94.2, C98.1, L16.2
unnamed: C99.1, L16.1, L17.1, TC3.1
unnamed: C100.1, L18.2, TC4.1
unnamed: C101.1, L17.2, L18.1, L19.2
unnamed: C102.1, C103.1, K1.8, L19.1
unnamed: C104.1, R75.2, R76.1
unnamed: D1.1 (K), K1.16, Q1.2 (C)
unnamed: D2.1 (K), D3.2 (A), K1.6, L1.2 (TAP)
unnamed: C84.1, D4.2 (A), D6.2 (A), L12.1 (SA)
unnamed: D4.1 (K), VR5.1
unnamed: D5.2 (A), VR5.3
unnamed: C84.2, D5.1 (K), D7.1 (K), L12.3 (SB)
unnamed: D6.1 (K), VR6.1
unnamed: D7.2 (A), VR6.3
unnamed: C103.2, D8.1 (K), D9.2 (A)
unnamed: D9.1 (K), Q20.3 (B), R71.1
unnamed: D10.1 (K), U7.8 (VIN)
unnamed: J1.1, K1.4
unnamed: J3.1, R17.1
unnamed: C22.1, J3.2, Q7.3 (G), Q21.2 (C), R4.1
unnamed: C36.1, J4.7 (A0), U3.4 (OUT)
unnamed: J4.3 (SCL), J8.2 (SCL), U6.2 (SCL), U7.6 (D5/SCL)
unnamed: J4.4 (SDA), J8.1 (SDA), U6.3 (SDA), U7.5 (D4/SDA)
unnamed: J4.1 (VDD), R73.1, R79.1, U7.10 (3V3)
unnamed: J5.1, R38.2
unnamed: C45.2, C46.1, J5.2
unnamed: C48.2, J6.1
unnamed: C57.1, J7.2, R43.2
unnamed: J9.1, Q20.2 (C)
unnamed: J9.2, R72.1
unnamed: J10.1, U7.4 (D3/A3)
unnamed: J10.2, U7.2 (D1/A1)
unnamed: J10.3, U7.12 (D9/MISO)
unnamed: J11.2, U7.7 (D6/TX)
unnamed: J11.3, U7.14 (D7/RX)
unnamed: J12.1, R80.2
unnamed: C9.1, L2.2 (TAP)
unnamed: L3.4 (AA), R8.1
unnamed: C8.1, L3.1 (SA), Q4.3 (D)
unnamed: L4.2, Y1.1
unnamed: L12.4 (AA), Q17.1 (G)
unnamed: C88.2, L13.4 (AA)
unnamed: C86.1, L13.1 (SA), Q17.3 (D)
unnamed: C92.1, L14.4 (AA)
unnamed: C90.1, L14.1 (SA), Q18.2 (C)
unnamed: Q1.3 (B), R1.1, R2.2
unnamed: Q2.1 (D), Q3.2 (S)
unnamed: C1.1, L1.1, Q2.3 (G), TC1.1
unnamed: C2.1, Q2.2 (S), R3.1
unnamed: C4.1, L2.1, Q3.1 (D), R5.2, TC2.1
unnamed: C3.1, Q3.3 (G), R4.2
unnamed: C5.1, Q4.1 (G), R6.1
unnamed: C6.1, Q4.2 (S), R7.1
unnamed: C12.2, Q5.3 (B), R11.2, R12.1
unnamed: C15.1, Q5.2 (C), R13.2
unnamed: Q5.1 (E), R14.1
unnamed: Q6.1 (D), Q7.2 (S)
unnamed: Q6.3 (G), R16.1, Y6.2
unnamed: C23.1, Q6.2 (S), R18.1
unnamed: C24.1, C25.1, L5.2, Q7.1 (D), R21.1
unnamed: C29.2, Q8.3 (B), R22.2, R23.1
unnamed: C31.1, C32.1, L6.2, Q8.2 (C)
unnamed: Q8.1 (E), R24.1
unnamed: Q9.3 (B), R28.2, R29.1
unnamed: Q9.2 (C), R29.2, R30.1, R31.1
unnamed: C39.2, Q10.3 (B), R32.1
unnamed: C40.1, Q10.2 (C), R32.2, R33.1
unnamed: C42.1, Q11.3 (B), R34.2, R35.1
unnamed: C44.1, Q11.2 (C), R35.2, R37.1
unnamed: C43.1, Q11.1 (E), R36.1
unnamed: C45.1, Q12.3 (B), R39.2
unnamed: C48.1, Q12.2 (C), Q13.2 (C), R39.1, R40.2
unnamed: C47.1, Q12.1 (E), R41.1
unnamed: C46.2, Q13.3 (B), R40.1
unnamed: C57.2, Q14.3 (B), R44.2
unnamed: C58.1, Q14.2 (C), R44.1, R45.2
unnamed: Q14.1 (E), R46.1
unnamed: C70.2, Q15.3 (B), R57.2
unnamed: C71.1, Q15.2 (C), R57.1, R62.2
unnamed: Q15.1 (E), R58.1
unnamed: C72.2, Q16.3 (B), R59.2
unnamed: C73.1, Q16.2 (C), R59.1, R61.2
unnamed: Q16.1 (E), R60.1
unnamed: C85.1, Q17.2 (S), R65.1
unnamed: C88.1, Q18.3 (B), R66.2, R67.1
unnamed: C89.1, Q18.1 (E), R68.1
unnamed: C94.1, Q19.3 (D), RFC1.2
unnamed: L15.2, Q19.1 (G), R69.1
unnamed: Q21.3 (B), R76.2
unnamed: Q22.3 (B), R77.2, R78.1
unnamed: Q22.2 (C), R79.2, U7.1 (D0/A0)
unnamed: R69.2, VR7.2
unnamed: R70.2, VR7.1
unnamed: C13.1, U1.6 (BYP)
unnamed: C10.2, U1.7 (CARR)
unnamed: C12.1, R10.1, U1.3 (OUT2)
unnamed: C9.2, U1.5 (SIG)
unnamed: C11.1, C27.1, C50.1, R26.1, U1.1 (V+), U2.1 (V+), U4.1 (VO)
unnamed: C28.1, U2.6 (BYP)
unnamed: C26.2, U2.7 (CARR)
unnamed: C37.1, R27.1, U2.3 (OUT2)
unnamed: C25.2, U2.5 (SIG)
unnamed: C35.1, R26.2, U3.6 (ENB), U3.7 (VPS)
unnamed: C33.1, U3.1 (INM)
unnamed: C32.2, U3.8 (INP)
unnamed: C34.1, U3.3 (OFS)
unnamed: C62.1, R48.2, R49.1, U5.3 (+)
unnamed: R50.1, R51.2, U5.2 (-)
unnamed: U5.6 (-), U5.7
unnamed: C74.2, U6.5 (CLK0)
unnamed: C75.2, U6.6 (CLK1)
unnamed: R19.1, U6.7 (CLK2)
unnamed: C108.1, U6.1 (VDDO), U6.8 (VDD), U9.1 (VO)
unnamed: R52.1, R73.2, R74.1, U7.3 (D2/A2)
unnamed: R55.2, U7.13 (D8/SCK)
unnamed: R53.2, R75.1, U7.11 (D10/MOSI)
unnamed: C106.1, L20.2, U8.3 (VI)
RX12V: C7.1, C8.2, C24.2, C49.1, C51.1, C52.1, C53.1, C54.1, C55.1, C105.1, K1.11, L2.3, L3.3 (SB), L5.1, L6.1, R5.1, R11.1, R13.1, R17.2, R22.1, R30.2, R33.2, R37.2, R41.2, U4.3 (VI)

Notes on the sheet:
混合後増幅・L 整合
合成・平衡変調
DDS
局発 = 受信 − 12MHz（CLK0 → Q4 → L3）
S メーター
音量（パネルの VR2）
第 1 混合
IF 増幅
送信音声の I/Q 生成（Ver 2.0）: マイク → L7 LPF → IC2A（約 21 倍）→ C65・R52 → U7 の A2（受信中は S メーター用の受信音）→ 複素 FIR（16 kHz、127 タップ、300〜2700 Hz）→ PDM（D8 = Q、D10 = I。D10 は受信中は AGC の PWM）→ 2 段 RC（約 15 kHz）→ C72・C70。送信検出は D0 へ移動
SSB フィルタ（12MHz ラダー）
スピーカー
Q9 はプリアンプ（V2 改）、Q10・Q11 は電圧増幅、Q13・Q12 は出力段（スピーカー 8Ω）
積検波
低周波増幅
AF PSN・信号分割
IF 増幅は Q7・Q6（2SK192A カスコード）。R18 は Q6 のソース抵抗
受信部（V2: 12MHz の SSB シングルスーパー）
IF 増幅（Q7・Q6）の出力を AD8307 で測る → ADS1015 → XIAO（I2C 0x48）
RF PSN
BFO = CLK2（R19・R20 で約 90mV）
J4 は秋月 AE-ADS1015（立てて差す）
水晶 6 個は同じロットから直列共振 ±50Hz 以内を選ぶ
入力同調・RF 増幅（50MHz）
終段増幅
受信 5V・パスコン
励振増幅
マイクアンプ
AGC 出力・送信検出（XIAO）。V2: S メーターは AD8307 → AE-ADS1015（上の受信部） AGC は Q21 で IF 増幅 Q7 と RF 増幅 Q3 のゲートを下げる方向のみ。最大ゲインは J3 の VR1 で設定（VR1 必須）
L1（入力同調）→ 2SK192A カスコード（Q2・Q3）→ L2（出力同調）。RF 段にも AGC・RF ゲインが効く
RF ゲイン（パネルの VR1）
AGC は Q21 で G2 を下げる
1.5kΩ → 330Ω（ラダーの終端）

Board: 4 copper layers, 134.0 x 129.6 mm, 285 parts (0 on the bottom side), 160 nets.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
HS1: 17PB046; Heatsink_17PB046

Their connections:
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

File kicad/bom.csv (part):

"Reference","Value","Footprint","Qty","DNP"
"C1","10p","Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm","1",""
"C2,C3,C5-C7,C9,C10,C12,C15,C22,C23,C25,C26,C29,C32-C34,C51,C52,C54,C74,C75,C82,C83,C85,C87-C89,C91,C110","0.01u","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P2.50mm","30",""
"C4,C100,C103","5p","Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm","3",""
"C8","27p","Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm","1",""
"C11,C13,C14,C27,C28,C30,C35,C36,C41-C43,C49,C53,C64,C109","0.1u","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P2.50mm","15",""
"C16,C84,C86,C90","15p","Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm","4",""
"C17,C21","82p","Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm","2",""
"C18,C20","100p","Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm","2",""
"C19","120p","Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm","1",""
"C24,C31","33p","Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm","2",""
"C37,C39,C40,C44-C46,C104","1u","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P2.50mm","7",""
"C38","0.047u","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P2.50mm","1",""
"C47,C48,C96","100u","Capacitor_THT:CP_Radial_D6.3mm_P2.50mm","3",""
"C50,C55,C58,C61,C63,C105-C108","10u","Capacitor_THT:CP_Radial_D5.0mm_P2.00mm","9",""
"C56","47u","Capacitor_THT:CP_Radial_D5.0mm_P2.00mm","1",""
"C57,C62,C65,C70-C73","1u","Capacitor_THT:CP_Radial_D5.0mm_P2.00mm","7",""
"C59","0.01u","PSN_TRX:C_Radial_D5.0mm_P2.00mm_CPpad","1",""
"C60","0.068u","PSN_TRX:C_Radial_D5.0mm_P2.00mm_CPpad","1",""
"C66-C69","3300p","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P2.50mm","4",""
"C76-C79","47PF","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P2.50mm","4",""
"C80,C81","0.001u","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P2.50mm","2",""
"C92","150pF","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","1",""
"C93","33pF","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","1",""
"C94","0.001u","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","1",""
"C95,C97","0.1uF","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","2",""
"C98","39p","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","1",""
"C99","82p","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","1",""
"C101","100p","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","1",""
"C102","68p","Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm","1",""
"D1","1N4001","Diode_THT:D_DO-41_SOD81_P10.16mm_Horizontal","1",""
"D2,D3","1N4148","Diode_THT:D_DO-35_SOD27_P2.54mm_Vertical_CathodeUp","2",""
"D4-D9","1N60","Diode_THT:D_DO-35_SOD27_P2.54mm_Vertical_CathodeUp","6",""
"D10","1N5819","Diode_THT:D_DO-41_SOD81_P5.08mm_Vertical_AnodeUp","1",""
"J1","RF_IN","PSN_TRX:SolderWire_1x02_P2.54mm_D1.1mm","1",""
"J2","PWR_IN","PSN_TRX:SolderWire_1x02_P5.08mm_D1.1mm","1",""
"J3,J5","Volume","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","2",""
"J4","AE-ADS1015","PSN_TRX:AE-ADS1015_Vertical","1",""
"J6","SP-OUT","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1",""
"J7","MIC-IN","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical","1",""
"J8","I2C_OUT-LCD","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","1",""
"J9","TX-ON-LED","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1",""
"J10","Encoder","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical","1",""
"J11","NX4832K035","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical","1",""
"J12","POWER-LED","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1",""
"K1","G5V-2 DC12","PSN_TRX:Relay_DPDT_Omron_G5V-2_D1.0mm","1",""
"L1","T30-6 11T/2T","PSN_TRX:L_T30_3pin_Vertical","1",""
"L2","T30-6 11T/3T","PSN_TRX:L_T30_3pin_Vertical","1",""
"L3,L12-L14","7T50","PSN_TRX:L_FCZ07S_CT","4",""
"L4","8.2uH","PSN_TRX:L_AL0510-153K_Vertical","1",""
"L5,L6","4.7uH","PSN_TRX:L_AL0510-153K_Vertical","2",""
"L7","15mH","PSN_TRX:L_AL0510-153K_Vertical","1",""
"L8,L9","100nH","PSN_TRX:L_AL0510-153K_Vertical","2",""
"L10,L11","1mH","PSN_TRX:L_AL0510-153K_Vertical","2",""
"L15","270nH","Inductor_THT:L_Axial_L9.5mm_D4.0mm_P2.54mm_Vertical_Fastron_SMCC","1",""
"L16","T-50-10 9T/0.6mm","PSN_TRX:L_T50_2pin_Vertical","1",""
"L17","T-50-10 10T/0.6mm","PSN_TRX:L_T50_2pin_Vertical","1",""
"L18","T-30-6 8T/0.4mm","PSN_TRX:L_T30_2pin_Vertical","1",""
"L19","T-50-10 8T/0.6mm","PSN_TRX:L_T50_2pin_Vertical","1",""
"L20","10uH","PSN_TRX:L_AL0510-153K_Vertical","1",""
"LED1","LED黄","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1","未実装(DNP)"
"Q1","2SA1015","Package_TO_SOT_THT:TO-92_Inline","1",""
"Q2,Q3,Q6,Q7","2SK192A","Package_TO_SOT_THT:TO-92_Inline","4",""
"Q4,Q17","2SK439","Package_TO_SOT_THT:TO-92_Inline","2",""
"Q5,Q8-Q11,Q14-Q16,Q18,Q20-Q22","2SC1815","Package_TO_SOT_THT:TO-92_Inline","12",""
"Q12","2SA950","Package_TO_SOT_THT:TO-92_Inline","1",""
"Q13","2SC2120","Package_TO_SOT_THT:TO-92_Inline","1",""
"Q19","RD06HVF1","Package_TO_SOT_THT:TO-220-3_Vertical","1",""
"R1,R12,R23,R43,R61,R62,R67","4.7k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","7",""
"R2,R39,R40,R75,R78-R80","10k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","7",""
"R3,R9,R18,R20,R68","100","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","5",""
"R4,R6,R29,R32,R35,R44,R48,R49,R71,R73,R74","100k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","11",""
"R5,R21","2.2k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2",""
"R7,R65","51","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2",""
"R8","470","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1",""
"R10,R27,R30,R31,R33,R36,R37,R42,R45,R50,R72","1k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","11",""
"R11,R22","27k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2",""
"R13,R34","1.5k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2",""
"R14","33","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1",""
"R15","180","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1",""
"R16,R38,R46","330","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","3",""
"R17,R51,R66","20k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","3",""
"R19","1.2k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1",""
"R24","27","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1",""
"R25","220","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1",""
"R26","10","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1",""
"R28","8.2k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1",""
"R41","100 1W","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1",""
"R47","620","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1",""
"R52","22k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1",""
"R53-R56","3.3k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","4",""
"R57,R59","1M","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2",""
"R58,R60","22","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2",""
"R63,R64","47","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2",""
"R69","10","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical","1",""
"R70","330","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical","1",""
"R76,R77","47k","Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2",""
"RFC1","10uH","Inductor_THT:L_Axial_L14.0mm_D4.5mm_P15.24mm_Horizontal_Fastron_LACC","1",""
"TC1-TC3","30p","PSN_TRX:C_Trimmer_TMCV01","3",""
"TC4","10p","PSN_TRX:C_Trimmer_TMCV01","1",""
"U1,U2","NJM2594V","Package_SO:TSSOP-8_4.4x3mm_P0.65mm","2",""
"U3","AD8307ANZ","Package_DIP:DIP-8_W7.62mm","1",""
"U4","78L05","Package_TO_SOT_THT:TO-92_Inline","1",""
"U5","NJM2904","Package_DIP:DIP-8_W7.62mm","1",""
"U6","Si5351_DIP8","PSN_TRX:DIP-8_W7.62mm","1",""
"U7","Seeeduino_XIAO_Socket","PSN_TRX:Seeeduino_XIAO_Socket","1",""
"U8","R-78E5.0-1.0","PSN_TRX:DCDC_RECOM_R-78E_78Lxx-pinmap","1",""
"U9","LP2950-3.3_TO92","Package_TO_SOT_THT:TO-92_Inline","1",""
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

Notices in the files:
README.md:
[Etherkit Si5351](https://github.com/etherkit/Si5351Arduino) | Jason Milldrum (NT7S) | GPL v3 | Si5351 制御（ファームウェア）
Arduino-ESP32（Preferences ほか） | Espressif Systems | LGPL 2.1 | ESP32-C3 コア
[KiCad](https://www.kicad.org/) 標準シンボル・フットプリントライブラリ | KiCad Library Team | CC-BY-SA 4.0（設計への利用は例外規定により制限なし） | 回路図・基板
[OpenSCAD](https://openscad.org/) | OpenSCAD 開発チーム | GPL v2 | ケース設計
GNU General Public License v3.0** の下で公開しています。全文は [`LICENSE`](LICENSE) を参照してください。
Copyright (C) 2026 JA6FUF (kazushinjo)
it under the terms of the GNU General Public License as published by
